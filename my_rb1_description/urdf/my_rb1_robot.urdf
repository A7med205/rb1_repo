Commit message: Modified the launch file, spawned the model and changed its color and position

File: my_rb1_description/urdf/my_rb1_robot.urdf (robot description, URDF)
Before this commit: robot simple_cylinder_robot, 7 links, 6 joints
Links:
- link back_caster: mass None -> 0.25
